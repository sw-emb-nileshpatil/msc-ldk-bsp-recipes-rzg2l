# Copyright (C) 2020 AVNET Integrated, MSC Technologies GmbH
# Released under the MIT license (see COPYING.MIT for the terms)

require ../../../../../meta-msc-ldk-core-recipes.git/msc-git.inc
require msc-git-src.inc

DEFCONFIG = "msc_sm2s_imx8m_defconfig"
SRCREV = "efdbe17fd89ec46ac328f98a421566037647eeb2"

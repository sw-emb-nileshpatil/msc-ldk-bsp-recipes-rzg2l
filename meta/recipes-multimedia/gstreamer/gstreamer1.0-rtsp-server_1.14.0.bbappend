# Copyright (C) 2019 AVNET Integrated, MSC Technologies GmbH

FILESEXTRAPATHS_prepend := "${BSPDIR}/sources/yocto.git/meta/recipes-multimedia/gstreamer/gstreamer1.0-rtsp-server:"
FILESEXTRAPATHS_prepend := "${BSPDIR}/sources/yocto.git/meta/recipes-multimedia/gstreamer/files:"

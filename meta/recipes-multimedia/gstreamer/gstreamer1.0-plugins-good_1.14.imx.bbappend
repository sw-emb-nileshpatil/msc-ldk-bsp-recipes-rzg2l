# Copyright (C) 2019 AVNET Integrated, MSC Technologies GmbH

FILESEXTRAPATHS_prepend := "${BSPDIR}/sources/meta-fsl-bsp-release.git/imx/meta-bsp/recipes-multimedia/gstreamer/gstreamer1.0-plugins-good:"
FILESEXTRAPATHS_prepend := "${BSPDIR}/sources/yocto.git/meta/recipes-multimedia/gstreamer/files:"

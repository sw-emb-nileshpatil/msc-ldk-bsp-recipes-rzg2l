# Copyright (C) 2021 AVNET Embedded, MSC Technologies GmbH

require ../../meta-msc-ldk-core.git/recipes-core/images/msc-image-base.bb
require common.inc
require weston.inc

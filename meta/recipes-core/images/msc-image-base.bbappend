# Copyright (C) 2021 AVNET Embedded, MSC Technologies GmbH

require common.inc

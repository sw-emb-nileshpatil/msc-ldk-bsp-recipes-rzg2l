# Copyright (C) 2019 AVNET Integrated, MSC Technologies GmbHs
LICENSE = "MIT"

require msc-image-qt5.inc
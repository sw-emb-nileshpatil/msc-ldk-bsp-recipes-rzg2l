FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"

SRC_URI += "file://0001-Fix-open-with-O_CREAT-in-second-argument-needs-3-arg.patch"


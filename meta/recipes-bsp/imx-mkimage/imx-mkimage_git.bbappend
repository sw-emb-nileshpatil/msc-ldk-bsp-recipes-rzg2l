# Copyright (C) 2020 AVNET Integrated, MSC Technologies GmbH

require imx-mkimage_git.inc

# Copyright (C) 2019 AVNET Integrated, MSC Technologies GmbH
DESCRIPTION = "i.MX U-Boot suppporting i.MX reference boards."

require ../../../../../meta-msc-ldk-core-recipes.git/msc-git.inc
require msc-git-src.inc

SRCREV = "96ff08a1c27a9c37f2839f7d1d60fd2941dca4cf"

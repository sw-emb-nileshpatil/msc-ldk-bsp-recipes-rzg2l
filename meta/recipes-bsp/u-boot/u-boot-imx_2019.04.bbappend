# Copyright (C) 2020 AVNET Integrated, MSC Technologies GmbH
DESCRIPTION = "i.MX U-Boot suppporting i.MX reference boards."

require ../../../../../meta-msc-ldk-core-recipes.git/msc-git.inc
require msc-git-src.inc

SRCREV = "e74e5c60664fe75a4aad3c93f1961cf647fe83c7"

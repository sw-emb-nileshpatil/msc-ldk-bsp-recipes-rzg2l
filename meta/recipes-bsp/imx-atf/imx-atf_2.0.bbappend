# Copyright (C) 2020 AVNET Integrated, MSC Technologies GmbH
DESCRIPTION = "i.MX U-Boot suppporting i.MX reference boards."

require ../../../../../meta-msc-ldk-core-recipes.git/msc-git.inc
require msc-git-src.inc

SRCREV = "9cb56dd248fdacb24c003bb7ba952b66cc5184b5"

do_compile_prepend() {
        if [ "${MACHINE}" = "sm2s-rzg2ul" ]; then
                BOARD="RZG2UL_SMARC";
        fi
}

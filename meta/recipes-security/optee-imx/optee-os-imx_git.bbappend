# Copyright (C) 2019 AVNET Integrated, MSC Technologies GmbH

PLATFORM_FLAVOR_m2s-imx8mm-qc-001 = "mx8mmevk"

# Copyright (C) 2020 AVNET Integrated, MSC Technologies GmbH

FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"

SRC_URI += "file://0001-Add-aarch64-support.patch"


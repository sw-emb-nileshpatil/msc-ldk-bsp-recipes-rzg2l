# Copyright (C) 2019 AVNET Integrated, MSC Technologies GmbH

SRC_URI_remove = "file://0001-Added-commandline-parameter-to-chose-connector-and-r.patch"

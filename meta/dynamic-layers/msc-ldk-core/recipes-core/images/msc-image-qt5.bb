# Copyright (C) 2022 AVNET Embedded, MSC Technologies GmbH

require msc-image-weston.bb
require ../../meta-renesas.git/dynamic-layers/qt5-layer/images/core-image-qt.bb

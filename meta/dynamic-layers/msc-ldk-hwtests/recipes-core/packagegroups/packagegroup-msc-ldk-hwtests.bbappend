# Copyright (C) 2019 AVNET Integrated, MSC Technologies GmbH

RDEPENDS_${PN}_remove = " \
    hwtest-audio \
    "

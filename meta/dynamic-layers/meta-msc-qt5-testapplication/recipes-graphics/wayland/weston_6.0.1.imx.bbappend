FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"

SRC_URI += "file://0001-weston.ini.-Disable-panel.-Cleanup.patch"

